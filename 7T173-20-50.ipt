# Autodesk Inventor part: 7T173-20-50
## iProperties
Created: 2008-02
Part Number: 7T173-20-50
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
